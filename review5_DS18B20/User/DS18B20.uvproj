# Keil uVision project DS18B20.uvproj, settings and files
target DS18B20 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: DS18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\Sys
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: init.c smg.c
  group Sys
    ../Sys/: onewire.c
